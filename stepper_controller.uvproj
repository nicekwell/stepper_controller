# Keil uVision project stepper_controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C58 SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(33000000)
  output: stepper_controller +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\include
  group Source Group 1
    ./src/: main.c 1602.c
